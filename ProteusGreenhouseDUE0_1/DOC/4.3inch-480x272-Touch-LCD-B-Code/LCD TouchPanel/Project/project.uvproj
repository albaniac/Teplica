# Keil uVision project project.uvproj, settings and files
target Open1788 (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: project
  c flags: Optim=1
  c include: ..\Libraries\Core\CM3\CoreSupport;..\Libraries\Core\CM3\DeviceSupport\NXP\LPC177x_8x;..\Libraries\Drivers\include;..\User;..\Libraries\BoardSupport
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group User
    ../User/: main.c timer.c
    ../User/EX_SDRAM/: EX_SDRAM.c
    ../User/LCD/: lpc177x_8x_lcd.c logo.c AsciiLib.c
    ../User/TouchPanel/: TouchPanel.c
  group Startup
    ../Libraries/Core/CM3/DeviceSupport/NXP/LPC177x_8x/startup/arm/: startup_LPC177x_8x.s
  group CMSIS-CMS
    ../Libraries/Core/CM3/DeviceSupport/NXP/LPC177x_8x/: system_LPC177x_8x.c
    ../Libraries/Core/CM3/CoreSupport/: core_cm3.c
  group Drivers
    ../Libraries/Drivers/source/: lpc177x_8x_gpio.c lpc177x_8x_systick.c lpc177x_8x_clkpwr.c lpc177x_8x_ssp.c lpc177x_8x_uart.c debug_frmwrk.c lpc177x_8x_pinsel.c
